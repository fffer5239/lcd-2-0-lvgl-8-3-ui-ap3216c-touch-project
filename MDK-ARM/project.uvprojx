# Keil uVision project project.uvprojx, settings and files
target project (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP;../BSP/lckfb_log;../BSP/lcd;../BSP/soft_i2c;../BSP/touch;../LIB/LVGL-8.3/examples/porting;../LIB/LVGL-8.3/src/hal;..\BSP\ap3216c;..\App\lcd-lvgl-test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group APP
    ../App/lcd-lvgl-test/: ui_test.c
  group BSP/lcd
    ../BSP/lcd/: bsp_backlight.c st7789.c st7789_font.c st7789_port.c
  group BSP/lckfb_log
    ../BSP/lckfb_log/: lckfb_log.c lckfb_log_port.c
  group BSP/touch
    ../BSP/touch/: ft6336_drv.c
  group BSP/soft_i2c
    ../BSP/soft_i2c/: soft_i2c.c soft_i2c_port.c
  group BSP/ap3216c
    ../BSP/ap3216c/: ap3216c.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group LVGL-8-3
    ../LIB/LVGL-8.3/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../LIB/LVGL-8.3/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LIB/LVGL-8.3/src/extra/: lv_extra.c
    ../LIB/LVGL-8.3/src/extra/layouts/flex/: lv_flex.c
    ../LIB/LVGL-8.3/src/extra/layouts/grid/: lv_grid.c
    ../LIB/LVGL-8.3/src/extra/libs/bmp/: lv_bmp.c
    ../LIB/LVGL-8.3/src/extra/themes/basic/: lv_theme_basic.c
    ../LIB/LVGL-8.3/src/extra/widgets/animimg/: lv_animimg.c
    ../LIB/LVGL-8.3/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LIB/LVGL-8.3/src/extra/widgets/chart/: lv_chart.c
    ../LIB/LVGL-8.3/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LIB/LVGL-8.3/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LIB/LVGL-8.3/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LIB/LVGL-8.3/src/extra/widgets/led/: lv_led.c
    ../LIB/LVGL-8.3/src/extra/widgets/list/: lv_list.c
    ../LIB/LVGL-8.3/src/extra/widgets/menu/: lv_menu.c
    ../LIB/LVGL-8.3/src/extra/widgets/meter/: lv_meter.c
    ../LIB/LVGL-8.3/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LIB/LVGL-8.3/src/extra/widgets/span/: lv_span.c
    ../LIB/LVGL-8.3/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LIB/LVGL-8.3/src/extra/widgets/spinner/: lv_spinner.c
    ../LIB/LVGL-8.3/src/extra/widgets/tabview/: lv_tabview.c
    ../LIB/LVGL-8.3/src/extra/widgets/tileview/: lv_tileview.c
    ../LIB/LVGL-8.3/src/extra/widgets/win/: lv_win.c
    ../LIB/LVGL-8.3/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../LIB/LVGL-8.3/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LIB/LVGL-8.3/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../LIB/LVGL-8.3/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../LIB/LVGL-8.3/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LIB/LVGL-8.3/src/extra/themes/default/: lv_theme_default.c
    ../LIB/LVGL-8.3/src/extra/themes/mono/: lv_theme_mono.c
  group LVGL_config
    ../LIB/LVGL-8.3/: lv_conf.h
  group LVGL_porting
    ../LIB/LVGL-8.3/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
software components: CMSIS:CORE 5.6.0
